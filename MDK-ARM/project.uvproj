# Keil uVision project project.uvproj, settings and files
target STM32F401RE (ARM-ADS)
  device: STM32F401RE STMicroelectronics
  pack: Keil.STM32F4xx_DFP.1.0.8
  cpu: IROM(0x08000000,0x60000) IRAM(0x20000000,0x18000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: project
  c flags: Optim=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER STM32F401xx HSE_VALUE=8000000
  c misc: --c99
  c include: ..\CMSIS\Include;..\CMSIS\Device\ST\STM32F4xx\Include;..\App\include;..\Api\include;..\STM32F4xx_StdPeriph_Driver\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x60000
  memory RVCT9: RAM 0x20000000 size 0x18000
  group App
    ../App/: retarget.c main.c
  group driver
    ../STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_tim.c stm32f4xx_usart.c
  group mcu
    ../CMSIS/Device/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c
    ../CMSIS/Device/ST/STM32F4xx/Source/Templates/arm/: startup_stm32f401xx.s
  group Api
    ../Api/: com.c led.c
